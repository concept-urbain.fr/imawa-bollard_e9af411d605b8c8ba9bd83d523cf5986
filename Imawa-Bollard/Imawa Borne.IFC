Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: IMAW-BOR-AB-001.IFC
Time: 2020-07-01T13:39:41
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: IMAW-BOR-AS-002-02_Defaut
In: Default Storey
PSet_Mass_Property - Mass Measure: 29.8989; Area Measure: 1.25881; Volume Measure: 0.00463873

# IfcBuildingElementProxy: IMAW-BOR-AS-003_Default
In: Default Storey
Material: FGS 400-15

# IfcBuildingElementProxy: MULT-AB-001_Default
In: Default Storey
Material: S 235
